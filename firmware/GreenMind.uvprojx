# Keil uVision project GreenMind.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GreenMind +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\lsens;.\APP\ws2812;.\APP\tftlcd;.\APP\dht11;.\APP\agriculture;.\APP\touch;.\APP\24Cxx;.\APP\iic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_fsmc.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/lsens/: lsens.c
    ./APP/ws2812/: ws2812.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/dht11/: dht11.c
    ./APP/agriculture/: app_state.c plant_assets_builtin.c asset_service.c ai_text_service.c font_service.c font_assets.s protocol.c sensor_service.c key_service.c ui_service.c touch_service.c
    ./APP/touch/: touch.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/iic/: iic.c
  group Public
    ./Public/: system.c SysTick.c usart.c
